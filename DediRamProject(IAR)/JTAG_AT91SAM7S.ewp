# IAR project JTAG_AT91SAM7S.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: C:\DediWare-master\Debug\Server\ICSupport\Binary\ramfucAT91SAM7S_ALN.bin
  ILINK.IlinkOutputFile: JTAG_AT91SAM7S.out
  ILINK.IlinkIcfFile: C:\DediRamProject(IAR)\Vector.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: c_start.c dbg.c dbg.h exceptions.c exceptions.h JTAG_AT91SAM7S.c main.c vector_ram.h vector_ram_AT91.c
