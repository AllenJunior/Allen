# IAR project JTAG_ATxmegaA3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: C:\DediWare-master\Debug\Server\ICSupport\Binary\ramfuncATxmegaE_ALN.bin
  ILINK.IlinkOutputFile: JTAG_ATxmegaA3.out
  ILINK.IlinkIcfFile: C:\DediRamProject(IAR)\Vector.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: c_start.c dbg.c dbg.h exceptions.c exceptions.h JTAG_ATxmegaA3.c main.c vector_ram.c vector_ram.h
