# IAR project MB95F.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: C:\DediWare(150902)\Debug\Server\ICSupport\Binary\ramfuncMB95F.bin
  ILINK.IlinkOutputFile: ext.out
  ILINK.IlinkIcfFile: C:\Users\Green\Documents\DediProgNP\DediRamProject(IAR)\Vector.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: C:\Users\Green\Documents\DediProgNP\3.0.0Rev5\Server\ICSupport\Binary\ramfuncMB95F.bin
  group (top)
    ./: c_start.c dbg.c dbg.h exceptions.c exceptions.h main.c MB95F.c vector_ram.c vector_ram.h
