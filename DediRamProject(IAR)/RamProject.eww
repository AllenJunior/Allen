<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DBG_MC96Fxxxx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ICP_Nu8051.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ICP_NUC505.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ICP_NuMicro.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IIC_78M6610.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IIC_IN602C.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IIC_IR35XX.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IIC_LP8860.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IIC_Multiramfunction.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IIC_NT0660.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IIC_Primarion.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IIC_ST_PM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IIC_WT61P8.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ISP_ATmega.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ISP_ATtinyX.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\JTAG_AT32UC3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\JTAG_AT91SAM7S.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\JTAG_ATxmegaA3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\JTAG_IRMCK.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\JTAG_Lattice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\JTAG_LatticeM4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\LED_Test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\simulate.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SMBUS_UCD90.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SP37.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SPI_iCE40.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SPI_NPCE.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SPI_ZWAVE.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SWD_ATSAM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SWD_Cortex.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\template.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TPI_ATtinyX.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TTAG_A8XXX.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UART_MON8.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UART_N78.ewp</path>
  </project>
  <batchBuild/>
</workspace>


