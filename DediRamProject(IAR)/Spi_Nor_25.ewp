# IAR project Spi_Nor_25.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: C:\DediWare(150716)\Debug\Server\ICSupport\Binary\Spi_Nor_25_t.bin
  ILINK.IlinkOutputFile: _demo.out
  ILINK.IlinkIcfFile: Vector.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: c_start.c dbg.c dbg.h exceptions.c exceptions.h main.c Spi_Nor_25.c Vector.icf vector_ram.c vector_ram.h
